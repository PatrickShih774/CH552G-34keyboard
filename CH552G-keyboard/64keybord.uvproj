# Keil uVision project 64keybord.uvproj, settings and files
target Target 1 (MCS-51)
  device: CH551 WCH
  cpu: IRAM(0-0xFF) XRAM(0-0xFF)  IROM(0-0x3FFF) CLOCK(24000000)
  output: CH552G_Keyboard_Minimal +hex
  c flags: Optimize=9 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c div_usb.c keybord.c
